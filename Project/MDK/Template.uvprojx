# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: M453VG6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.7
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M4") CLOCK(12000000)
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\CORE\ARM;..\..\CORE\Include;..\..\CORE;..\..\Drivers\inc;..\..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CORE
    ../../CORE/ARM/: startup_M451Series.s
    ../../CORE/: system_M451Series.c
  group LIB
    ../../Drivers/src/: acmp.c can.c clk.c crc.c dac.c eadc.c ebi.c fmc.c gpio.c i2c.c pdma.c pwm.c retarget.c rtc.c sc.c scuart.c spi.c sys.c timer.c tk.c uart.c usbd.c wdt.c wwdt.c
  group USER
    ../../USER/: main.c
