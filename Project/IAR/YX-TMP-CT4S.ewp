# IAR project YX-TMP-CT4S.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VE ST STM32F103VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\Application; ..\..\System; ..\..\Drivers; ..\..\Libraries\inc; ..\..\System\Include; ..\..\System\iar; ..\..\GUI; ..\..\Modbus\modbus\ascii; ..\..\Modbus\modbus\functions; ..\..\Modbus\modbus\include; ..\..\Modbus\modbus\rtu; ..\..\Modbus\modbus\tcp; ..\..\Modbus\port; ..\..\Task; ..\..\ucos iii\uC-CPU; ..\..\ucos iii\uC-CPU\ARM-Cortex-M3\IAR; ..\..\ucos iii\uC-LIB; ..\..\ucos iii\uCOS_CONFIG; ..\..\ucos iii\uCOS-III\Ports\ARM-Cortex-M\Generic\IAR; ..\..\ucos iii\uCOS-III\Source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: YX-TMP-CT4S.hex
  ILINK.IlinkOutputFile: YX-TMP-CT4S.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group Application
    ../../Task/: global.c
    ../../Application/: include.h main.c mstr.c mstr.h
  group Drivers
    ../../Drivers/: ad7923.c ad7923.h adc.c adc.h ads1248.c ads1248.h delay.c delay.h ds1302.c ds1302.h ds18b20.c ds18b20.h flowPID.c flowPID.h fm24cl64.c fm24cl64.h key.c key.h lcd.c lcd.h ms5611.c ms5611.h pump.c pwm.h sys.c sys.h target.c target.h tempPID.c tempPID.h timer.c usart.c
  group GUI
    ../../GUI/: CH_SetWindow.c ConfigWindow.c Data_Window.c MainWindow.c PassWd_SetWindow.c SampWindow.c SysInfo.c
  group Libraries/inc
    ../../Libraries/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group Libraries/src
    ../../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Modbus/Modbus
    ../../Modbus/modbus/: mb.c
    ../../Modbus/modbus/ascii/: mbascii.c
    ../../Modbus/modbus/rtu/: mbcrc.c mbcrc.h mbrtu.c mbrtu.h
    ../../Modbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group Modbus/Port
    ../../Modbus/port/: port.c port.h portevent.c portserial.c porttimer.c
  group System
    ../../System/iar/: startup_stm32f10x_hd.s
    ../../System/: stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
  group Task
    ../../Task/: battertask.c flowcontroltask.c guitask.c keytask.c maintask.c rtctask.c tempcontroltask.c temppressTask.c temptask.c usarttask.c
  group UCOS III/UCOSIII-BSP
    ../../ucos iii/UCOS_BSP/: cpu_bsp.c
  group UCOS III/UCOSIII_CONFIG
    ../../ucos iii/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group UCOS III/UCOSIII_CORE
    ../../ucos iii/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_mon.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOS III/UCOSIII_CPU
    ../../ucos iii/uC-CPU/ARM-Cortex-M3/IAR/: cpu.h cpu_a.asm cpu_c.c
    ../../ucos iii/uC-CPU/: cpu_core.c
  group UCOS III/UCOSIII_LIB
    ../../ucos iii/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../ucos iii/uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group UCOS III/UCOSIII_PORT
    ../../ucos iii/uCOS-III/Ports/ARM-Cortex-M/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
